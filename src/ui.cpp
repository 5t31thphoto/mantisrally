// Size over speed here: this code runs per object or per frame, not per pixel or per sample, and the app shares
// flash with others (see README, "Footprint").
#pragma GCC optimize("Os")
#include "ui.h"
#include <ctype.h>
#include <string.h>

namespace mantis {

struct Glyph { char c; const char* rows[7]; };
static const Glyph G[] = {
    {'A', {".###.", "#...#", "#...#", "#####", "#...#", "#...#", "#...#"}}, {'B', {"####.", "#...#", "#...#", "####.", "#...#", "#...#", "####."}},
    {'C', {".###.", "#...#", "#....", "#....", "#....", "#...#", ".###."}}, {'D', {"####.", "#...#", "#...#", "#...#", "#...#", "#...#", "####."}},
    {'E', {"#####", "#....", "#....", "####.", "#....", "#....", "#####"}}, {'F', {"#####", "#....", "#....", "####.", "#....", "#....", "#...."}},
    {'G', {".###.", "#...#", "#....", "#.###", "#...#", "#...#", ".####"}}, {'H', {"#...#", "#...#", "#...#", "#####", "#...#", "#...#", "#...#"}},
    {'I', {".###.", "..#..", "..#..", "..#..", "..#..", "..#..", ".###."}}, {'J', {"..###", "...#.", "...#.", "...#.", "...#.", "#..#.", ".##.."}},
    {'K', {"#...#", "#..#.", "#.#..", "##...", "#.#..", "#..#.", "#...#"}}, {'L', {"#....", "#....", "#....", "#....", "#....", "#....", "#####"}},
    {'M', {"#...#", "##.##", "#.#.#", "#.#.#", "#...#", "#...#", "#...#"}}, {'N', {"#...#", "#...#", "##..#", "#.#.#", "#..##", "#...#", "#...#"}},
    {'O', {".###.", "#...#", "#...#", "#...#", "#...#", "#...#", ".###."}}, {'P', {"####.", "#...#", "#...#", "####.", "#....", "#....", "#...."}},
    {'Q', {".###.", "#...#", "#...#", "#...#", "#.#.#", "#..#.", ".##.#"}}, {'R', {"####.", "#...#", "#...#", "####.", "#.#..", "#..#.", "#...#"}},
    {'S', {".####", "#....", "#....", ".###.", "....#", "....#", "####."}}, {'T', {"#####", "..#..", "..#..", "..#..", "..#..", "..#..", "..#.."}},
    {'U', {"#...#", "#...#", "#...#", "#...#", "#...#", "#...#", ".###."}}, {'V', {"#...#", "#...#", "#...#", "#...#", "#...#", ".#.#.", "..#.."}},
    {'W', {"#...#", "#...#", "#...#", "#.#.#", "#.#.#", "#.#.#", ".#.#."}}, {'X', {"#...#", "#...#", ".#.#.", "..#..", ".#.#.", "#...#", "#...#"}},
    {'Y', {"#...#", "#...#", ".#.#.", "..#..", "..#..", "..#..", "..#.."}}, {'Z', {"#####", "....#", "...#.", "..#..", ".#...", "#....", "#####"}},
    {'0', {".###.", "#...#", "#..##", "#.#.#", "##..#", "#...#", ".###."}}, {'1', {"..#..", ".##..", "..#..", "..#..", "..#..", "..#..", ".###."}},
    {'2', {".###.", "#...#", "....#", "...#.", "..#..", ".#...", "#####"}}, {'3', {"#####", "...#.", "..#..", "...#.", "....#", "#...#", ".###."}},
    {'4', {"...#.", "..##.", ".#.#.", "#..#.", "#####", "...#.", "...#."}}, {'5', {"#####", "#....", "####.", "....#", "....#", "#...#", ".###."}},
    {'6', {"..##.", ".#...", "#....", "####.", "#...#", "#...#", ".###."}}, {'7', {"#####", "....#", "...#.", "..#..", ".#...", ".#...", ".#..."}},
    {'8', {".###.", "#...#", "#...#", ".###.", "#...#", "#...#", ".###."}}, {'9', {".###.", "#...#", "#...#", ".####", "....#", "...#.", ".##.."}},
    {'.', {".....", ".....", ".....", ".....", ".....", ".##..", ".##.."}}, {'-', {".....", ".....", ".....", ".###.", ".....", ".....", "....."}},
    {'/', {"....#", "....#", "...#.", "..#..", ".#...", "#....", "#...."}}, {':', {".....", ".##..", ".##..", ".....", ".##..", ".##..", "....."}},
    {'\'', {"..#..", "..#..", ".#...", ".....", ".....", ".....", "....."}},
    {'<', {"...#.", "..#..", ".#...", "#....", ".#...", "..#..", "...#."}}, {'>', {".#...", "..#..", "...#.", "....#", "...#.", "..#..", ".#..."}}, {'?', {".###.", "#...#", "....#", "...#.", "..#..", ".....", "..#.."}}, {',', {".....", ".....", ".....", ".....", ".##..", "..#..", ".#..."}}, {'!', {"..#..", "..#..", "..#..", "..#..", "..#..", ".....", "..#.."}},
    {'*', {"..#..", "..#..", "#####", ".###.", ".#.#.", "#...#", "....."}},
};

static const Glyph* find(char c) {
    c = (char)toupper((unsigned char)c);
    for (const Glyph& g : G) if (g.c == c) return &g;
    return nullptr;
}

int uiTextWidth(const char* s, int scale) { return (int)strlen(s) * 6 * scale - scale; }

static void plot(uint16_t* buf, int bw, int bh, int x, int y, uint16_t c) { if ((unsigned)x < (unsigned)bw && (unsigned)y < (unsigned)bh) buf[y * bw + x] = c; }

void uiText(uint16_t* buf, int bw, int bh, int x, int y, const char* s, uint16_t color, int scale, bool shadow) {
    for (int pass = shadow ? 0 : 1; pass < 2; pass++) {
        int cx = x;
        uint16_t c = pass == 0 ? rgb565(10, 12, 24) : color;
        int off = pass == 0 ? scale : 0;
        for (const char* p = s; *p; p++, cx += 6 * scale) {
            const Glyph* g = find(*p);
            if (!g) continue;
            for (int r = 0; r < 7; r++)
                for (int k = 0; k < 5; k++)
                    if (g->rows[r][k] == '#')
                        for (int dy = 0; dy < scale; dy++) for (int dx = 0; dx < scale; dx++) plot(buf, bw, bh, cx + k * scale + dx + off, y + r * scale + dy + off, c);
        }
    }
}

}
